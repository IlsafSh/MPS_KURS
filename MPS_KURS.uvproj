# Keil uVision project MPS_KURS.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S53 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(24000000) MODA2
  output: MPS_KURS
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
